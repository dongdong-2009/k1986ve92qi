# IAR project Backup of pult_v5.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fnp.h
  General.GHeapSize: 80
  General.GStackSize: 80
  ICC430.CCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F1611.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group hdr
    ./: AT45DB041B.h buttons.h buttons_def.h cos_sin_tbl.h file_def.h font_bmp.h gdef.h gl.h gl_def.h gps.h ico_bmp.h ico_bmp_alpha.h map_bmp.h menu.h menu_def.h modem.h modem_def.h MT12864.h MT12864_def.h serial.h sound.h strutils.h test_bmp.h time.h wav_tbl.h
  group src
    ./: AT45DB041B.c buttons.c cos_sin_tbl.c file.c file.h font_bmp.c gl.c gps.c ico_bmp.c ico_bmp_alpha.c main.c map_bmp.c menu.c modem.c MT12864.c serial.c sound.c strutils.c test_bmp.c time.c wav_tbl.c
